Commit message: works with LocoMani , standard environment

File: urdf/platform.urdf (robot description, URDF)
Before this commit: robot platform, 2 links, 0 joints
Joints:
- added joint cube: type fixed, parent base_link, child cube, origin xyz=0 0 0 rpy=0 0 0
